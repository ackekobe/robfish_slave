# Keil uVision project glider_slave.uvprojx, settings and files
target glider_slave (ARM-ADS)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: glider_slave +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,_CC_ARM,USE_USB_OTG_FS,__DEBUG
  c include: ..\CORE;..\USER;.\TestCode;..\FWLIB\inc;..\Include;..\FATFS\exfuns;..\FATFS\src;..\RT-Thread\inc;..\RT-Thread\libc;..\HardDriver\USB\STM32_USB_HOST_Library\Class\MSC\inc;..\HardDriver\USB\STM32_USB_HOST_Library\Core\inc;..\HardDriver\USB\STM32_USB_OTG_Driver\inc;..\HardDriver\USB\USB_APP;..\HardDriver\SD;..\HardDriver\sys;..\HardDriver\delay;..\HardDriver\usart;..\HardDriver\LED;..\HardDriver\LeakDetect;..\HardDriver\DS18B20;..\HardDriver\RF_Comm;..\HardDriver\SPI_Comm;..\HardDriver\CAN1;..\HardDriver\CAN2;..\HardDriver\RTC;..\Application\CRC8;..\Application\motor;..\Application;..\HardDriver\WDG;..\Application\Info_Record;..\HardDriver\ADC
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
    ./TestCode/: test.c
    ../Application/: motor_struct.h
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_rtc.c
  group RT-Thread
    ../RT-Thread/src/: board.c clock.c components.c context_rvds.S cpuport.c device.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c thread.c timer.c
    ../RT-Thread/inc/: rtconfig.h
  group HardDriver
    ../HardDriver/delay/: delay.c
    ../HardDriver/SD/: SD.c
    ../HardDriver/usart/: print_uart.c
    ../HardDriver/LED/: led.c
    ../HardDriver/LeakDetect/: leak.c
    ../HardDriver/DS18B20/: DS18B20.c
    ../HardDriver/sys/: sys.c
    ../HardDriver/RF_Comm/: RF.c
    ../HardDriver/SPI_Comm/: SPI_Slave.c
    ../HardDriver/CAN1/: CAN1.c
    ../HardDriver/CAN2/: CAN2.c
    ../HardDriver/RTC/: RTC.c
    ../HardDriver/WDG/: wdg.c
    ../HardDriver/ADC/: adc.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c fattester.c
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/src/option/: cc936.c
  group USB_OTG
    ../HardDriver/USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group USB_HOST
    ../HardDriver/USB/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../HardDriver/USB/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
  group USB_APP
    ../HardDriver/USB/USB_APP/: usb_bsp.c usbh_usr.c
  group Application
    ../Application/CRC8/: CRC8.c
    ../Application/motor/: motor.c
    ../Application/Info_Record/: Info_Record.c
